# Keil uVision project Smpl_DrvGPIO.uvproj, settings and files
target Smpl_GPIO (ARM-ADS)
  device: NUC120RE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: CodeTemplate +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM0;..\CMSIS\NUC1xx;..\BSP_Lib\Inc\Driver;..\BSP_Lib\Inc\NUC1xx-LB_002;..\BSP_Lib\Inc\System;..\BSP_Lib\Inc\USB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../CMSIS/CM0/: core_cm0.c
    ../CMSIS/NUC1xx/: system_NUC1xx.c
    ../CMSIS/STARTUP/: startup_NUC1xx.s
  group Source files
    ./: mpu_ctrl.c lcm.c Smpl_DrvGPIO.c hal_spi.c moto.c mpu6050.c nrf24l01.c mpu6050.h imu.c
  group Library files
    ../BSP_Lib/Src/Driver/: DrvPWM.c DrvUART.c DrvSYS.c retarget.c DrvGPIO.c DrvADC.c DrvTIMER.c DrvI2C.c
